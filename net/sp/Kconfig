## net/sp/Kconfig
```kconfig
#
# SP Domain Sockets
#

config SP
	tristate "SP domain sockets"
	---help---
	  Magic.
```
